# Repository elkel53930/daylight

## KiCad design elec/sub_boards/sub_boards.kicad_pcb

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C15, C16: C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D3: BAS516; D_SOD-523
H1, H2: M2.6; MountingHole_2.7mm
H3, H4, H5, H6: M2; MountingHole_2.1mm
J1: Conn_01x10; PinSocket_1x10_P2.54mm_Vertical
J2: PinSocket_1x07_P2.54mm_Vertical
J5, J6: PSR-41253-06O; JST_ZH_B6B-ZR_1x06_P1.50mm_Vertical
J8: Conn_01x07_Pin; JST_ZH_B7B-ZR_1x07_P1.50mm_Vertical
LS1: SMT-0440-T-2-R
SW1, SW2: TVBP06-B043CB-B; SW_PUSH_1P1T_6x3.5mm_H4.3_APEM_MJTP1243
U9, U10: AS5047D; TSSOP-14_4.4x5mm_P0.65mm

Connections:
+3.3V: BZ1.1 (+), D3.1 (K), J1.1, J2.2 (VCC), LS1.1
/BTN_A: J1.2, SW1.1
/BTN_B: J1.3, SW2.1
/BUZZER: BZ1.2 (-), D3.2 (A), J1.4, LS1.2
/CS: J1.9, J2.7 (CS)
/DC: J1.8, J2.6 (DC)
/ENCL_CS_L: J8.6, U9.1 (~CS)
/ENCL_CS_R: J5.6, J8.7
/ENCL_GND: C15.1, J5.2, J8.2, U9.5 (TST), U9.13 (GND)
/ENCL_MISO: J5.4, J8.4, U9.3 (MISO)
/ENCL_MOSI: J5.3, J8.3, U9.4 (MOSI)
/ENCL_SCK: J5.5, J8.5, U9.2 (CLK)
/ENCL__3V3: C15.2, J5.1, J8.1, U9.11 (VDD), U9.12 (VDD3V3)
/ENCR_CS_R: J6.1, U10.1 (~CS)
/ENCR_GND: C16.1, J6.5, U10.5 (TST), U10.13 (GND)
/ENCR_MISO: J6.3, U10.3 (MISO)
/ENCR_MOSI: J6.4, U10.4 (MOSI)
/ENCR_SCK: J6.2, U10.2 (CLK)
/ENCR__3V3: C16.2, J6.6, U10.11 (VDD), U10.12 (VDD3V3)
/MOSI: J1.6, J2.4 (SDA)
/RES: J1.7, J2.5 (RES)
/SCLK: J1.5, J2.3 (SCL)
GND: J1.10, J2.1 (GND), SW1.2, SW2.2

Notes on the sheet:
AS5047 SPI mode = 1 (Latch at fall edges)
from Enc L
Encoders

Board: 2 copper layers, 92.0 x 64.8 mm, 20 parts (2 on the bottom side), 23 nets.

## KiCad design elec/rpi_board/rpi_board.kicad_pcb

Parts:
C1, C6, C8, C9: CC0603KRX7R9BB104; C_0603_1608Metric
C2, C4, C5, C7: CL10A475KO8NNNC; C_0603_1608Metric
C3: CL32A107MPVNNNE; C_1210_3225Metric
D1: D-060306G1/SS2/G1; LED_0603_1608Metric
D2: KT-0603R; LED_0603_1608Metric
J1: B2B-ZR; JST_ZH_B2B-ZR_1x02_P1.50mm_Vertical
J2: Conn_01x10; PinSocket_1x10_P2.54mm_Vertical
J3: PinHeader; PinHeader_1x03_P2.54mm_Vertical
J4: FH12-22S-0.5SH; Hirose_FH12-22S-0.5SH_1x22-1MP_P0.50mm_Horizontal; Part Description 22 Position FFC, FPC Connector Contacts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
J5, J6: FSS-42085-03; PinHeader_2x03_P2.54mm_Vertical
Module1: ComputeModule4; Raspberry-Pi-4-Compute-Module; Part Description 100 Position Connector Receptacle, Cent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
Q1, Q2: IRLML6344; SOT-23
R1, R4, R7: 0603WAF1002T5E; R_0603_1608Metric
R2, R3, R5, R6, R8, R9, R10: 0603WAF1001T5E; R_0603_1608Metric
U1: MCP3221; SOT-23-5
U2: 74LVC1G07SE-7; SOT-353_SC-70-5; Part Description Buffer, Non-Inverting 1 Element 1 Bit p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

Connections:
+3V3CM: C1.1, C4.1, D1.2 (A), D2.2 (A), J2.1, J4.22, Module1.78 (GPIO_VREF(1.8v/3.3v_Input)), Module1.84 (+3.3v_(Output)), Module1.86 (+3.3v_(Output)), R2.2, R3.2, R8.2, R9.2, U1.1 (V_{DD}), U2.5 (VCC)
+5V: C3.2, C5.1, C6.1, C7.1, C8.2, C9.2, J3.2, J5.3, J6.5, J6.6, Module1.77 (+5v_(Input)), Module1.79 (+5v_(Input)), Module1.81 (+5v_(Input)), Module1.83 (+5v_(Input)), Module1.85 (+5v_(Input)), Module1.87 (+5v_(Input))
+BATT: J1.1, J6.1, J6.2, R4.2
/AD_SCL: Module1.56 (GPIO3), R2.1, U1.5 (SCL)
/AD_SDA: Module1.58 (GPIO2), R3.1, U1.4 (SDA)
/BTN_A: J2.2, Module1.24 (GPIO26)
/BTN_B: J2.3, Module1.26 (GPIO19)
/BUZZER: Module1.28 (GPIO13), Q2.1 (G), R7.2
/CAM1_C_N: J4.8, Module1.127 (CAM1_C_N)
/CAM1_C_P: J4.9, Module1.129 (CAM1_C_P)
/CAM1_D0_N: J4.2, Module1.115 (CAM1_D0_N)
/CAM1_D0_P: J4.3, Module1.117 (CAM1_D0_P)
/CAM1_D1_N: J4.5, Module1.121 (CAM1_D1_N)
/CAM1_D1_P: J4.6, Module1.123 (CAM1_D1_P)
/CAM1_D2_N: J4.11, Module1.133 (CAM1_D2_N)
/CAM1_D2_P: J4.12, Module1.135 (CAM1_D2_P)
/CAM1_D3_N: J4.14, Module1.139 (CAM1_D3_N)
/CAM1_D3_P: J4.15, Module1.141 (CAM1_D3_P)
/CAM_GPIO: J4.17, Module1.97 (Camera_GPIO)
/CS: J2.9, Module1.39 (GPIO8)
/DC: J2.8, Module1.45 (GPIO24)
/FSV_SIG: J3.1, Module1.55 (GPIO14)
/LIGHT: Module1.30 (GPIO6), Q1.1 (G), R1.2
/MOSI: J2.6, Module1.44 (GPIO10)
/RES: J2.7, Module1.41 (GPIO25)
/SCL0: J4.20, Module1.80 (SCL0), R8.1
/SCLK: J2.5, Module1.38 (GPIO11)
/SDA0: J4.21, Module1.82 (SDA0), R9.1
/USB_D+: J5.2, Module1.105 (USB2_P)
/USB_D-: J5.1, Module1.103 (USB2_N)
/nPWR_LED: Module1.95 (nPI_LED_PWR), U2.2
GND: C1.2, C2.2, C3.1, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, J2.10, J3.3, J4.1, J4.4, J4.7, J4.10, J4.13, J4.16, J4.19, J5.4, J5.5, J5.6, J6.3, J6.4, Module1.1 (GND), Module1.2 (GND), Module1.7 (GND), Module1.8 (GND), Module1.13 (GND), Module1.14 (GND), Module1.22 (GND), Module1.23 (GND), Module1.32 (GND), Module1.33 (GND), Module1.42 (GND), Module1.43 (GND), Module1.52 (GND), Module1.53 (GND), Module1.59 (GND), Module1.60 (GND), Module1.65 (GND), Module1.66 (GND), Module1.71 (GND), Module1.74 (GND), Module1.98 (GND), Module1.107 (GND), Module1.108 (GND), Module1.113 (GND), Module1.114 (GND), Module1.119 (GND), Module1.120 (GND), Module1.125 (GND), Module1.126 (GND), Module1.131 (GND), Module1.132 (GND), Module1.137 (GND), Module1.138 (GND), Module1.144 (GND), Module1.150 (GND), Module1.155 (GND), Module1.156 (GND), Module1.161 (GND), Module1.162 (GND), Module1.167 (GND), Module1.168 (GND), Module1.173 (GND), Module1.174 (GND), Module1.179 (GND), Module1.180 (GND), Module1.185 (GND), Module1.186 (GND), Module1.191 (GND), Module1.192 (GND), Module1.197 (GND), Module1.198 (GND), Q1.2 (S), Q2.2 (S), R1.1, R5.1, R7.1, U1.2 (V_{SS}), U2.3 (GND)
unnamed: D1.1 (K), R6.2
unnamed: D2.1 (K), R10.2
unnamed: J1.2, Q1.3 (D)
unnamed: J2.4, Q2.3 (D)
unnamed: Module1.88 (+1.8v_(Output)), Module1.90 (+1.8v_(Output))
unnamed: Module1.21 (PI_nLED_Activity), R6.1
unnamed: R10.1, U2.4
unnamed: C2.1, R4.1, R5.2, U1.3 (A_{IN})

Notes on the sheet:
CAM1_X_Xは等長配線
Camera Connectors
PWR LED
Activity LED
Power supply from main board 5V Max5A
FUTABAサーボモータ用のTXD
USB I/F for ESP32

Board: 4 copper layers, 70.0 x 66.6 mm, 32 parts (0 on the bottom side), 40 nets.

## KiCad design elec/main_board/main_board.kicad_pcb

Parts:
C1, C2, C3, C4, C9, C10: CL21A106KAYNNNE; C_0805_2012Metric
C8, C21, C22: CC0603KRX7R9BB104; C_0603_1608Metric
C18, C19: CL10A105KB8NNNC; C_0603_1608Metric
D1, D2: D-060306G1/SS2/G1; LED_0603_1608Metric
D3: KT-0603R; LED_0603_1608Metric
D6, D7: SFH4550
D8: SFH4550; SFH4550_Mirror
H1, H2, H3, H4, H5: M2.6 mounting hole; M2.6 Mounting Hole
H6, H7: M3 mounting hole; MountingHole_3.2mm_M3
J1, J2: Motor; PinHeader_1x02_P2.00mm_Vertical
J4: PinHeader; PinHeader_1x03_P2.54mm_Vertical
J7: Conn_01x02; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J11: B7B-ZR; JST_ZH_B7B-ZR_1x07_P1.50mm_Vertical
J13: B4B-ZR(LF)(SN); JST_ZH_B4B-ZR_1x04_P1.50mm_Vertical
Q1, Q2, Q3: IRLML6344; SOT-23
Q9, Q10: ST-1KL3A
Q11: ST-1KL3A; ST-1KL3A_Mirror
Q13: DMT6008LFG; Diodes_PowerDI3333-8
R1, R2, R9, R14, R15, R16: 0603WAF1002T5E; R_0603_1608Metric
R3, R4, R5, R23, R24, R25, R29: 0603WAF1001T5E; R_0603_1608Metric
R6, R7, R8, R26: 0603WAF4700T5E; R_0603_1608Metric
R10, R11, R12: 0603WAF1000T5E; R_0603_1608Metric
U2, U5: BD63573NUV; VSON-10-1EP_3x3mm_P0.5mm_EP1.2x2mm
U6: ESP32-S3-WROOM-1U
U11: LSM6DSR; Bosch_LGA-14_3x2.5mm_P0.5mm

Connections:
+3V3: C8.2, C9.2, C18.1, C19.1, C21.2, C22.2, D2.2 (A), D3.2 (A), J11.1, J13.1, Q9.2 (C), Q10.2 (C), Q11.2 (C), R23.1, R29.2, U2.1 (PS), U2.8 (VCC), U2.9 (PWM), U5.1 (PS), U5.8 (VCC), U5.9 (PWM), U6.2 (3V3), U11.5 (Vdd_IO), U11.8 (Vdd); also elsewhere on the board
+5V: D6.2 (A), D7.2 (A), D8.2 (A), J4.2, R26.2; also elsewhere on the board
+BATT: C1.2, C2.2, C3.2, C4.2, C10.2, J7.1, R1.2, R2.2, U2.7 (VM), U5.7 (VM); also elsewhere on the board
/BALL_DET: J13.2, R25.1, U6.22 (IO14)
/BAT_MON: R2.1, R3.1, U6.21 (IO13)
/CS_ENC_L: J11.6, U6.17 (IO9)
/CS_ENC_R: J11.7, U6.16 (IO46)
/CS_IMU: U6.34 (IO41), U11.12 (CS)
/CWCCW_L: U5.2 (INB), U6.24 (IO47)
/CWCCW_R: R9.2, U2.2 (INB), U6.26 (IO45)
/F_EN: Q2.1 (G), R15.2, U6.6 (IO6)
/F_SEN: Q10.1 (E), R7.2, U6.7 (IO7)
/LED_0: R4.1, U6.14 (USB_D+)
/LED_1: R5.1, U6.15 (IO3)
/L_EN: Q1.1 (G), R14.2, U6.8 (IO15)
/L_SEN: Q9.1 (E), R6.2, U6.9 (IO16)
/PWM_FAN: Q13.4 (G), R24.2, U6.38 (IO2)
/PWM_L: U5.3 (INA), U6.23 (IO21)
/PWM_R: U2.3 (INA), U6.25 (IO48)
/R_EN: Q3.1 (G), R16.2, U6.4 (IO4)
/R_SEN: Q11.1 (E), R8.2, U6.5 (IO5)
/SERVO_SIG1: J4.1, U6.39 (IO1)
/SPI1_MISO: J11.4, U6.19 (IO11)
/SPI1_MOSI: J11.3, U6.20 (IO12)
/SPI1_SCK: J11.5, U6.18 (IO10)
/SPI2_MISO: U6.31 (IO38), U11.1 (SDO/SA0)
/SPI2_MOSI: U6.32 (IO39), U11.14 (SDA)
/SPI2_SCK: U6.33 (IO40), U11.13 (SCL)
CHIP_PU: R23.2, U6.3 (EN); also elsewhere on the board
GND: C1.1, C2.1, C3.1, C4.1, C8.1, C9.1, C10.1, C18.2, C19.2, C21.1, C22.1, D1.1 (K), J4.3, J11.2, J13.4, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q13.1 (S), Q13.2 (S), Q13.3 (S), R3.2, R6.1, R7.1, R8.1, R9.1, R14.1, R15.1, R16.1, R24.1, R25.2, U2.5 (PGND), U2.10 (GND), U2.11 (PGND), U5.5 (PGND), U5.10 (GND), U5.11 (PGND), U6.1 (GND), U6.40 (GND), U6.41 (GND), U11.2 (SDx), U11.3 (SCx), U11.6 (GND), U11.7 (GND); also elsewhere on the board
GPIO0: R29.1, U6.27 (IO0); also elsewhere on the board
unnamed: D1.2 (A), R1.1
unnamed: D2.1 (K), R4.2
unnamed: D3.1 (K), R5.2
unnamed: D6.1 (K), R10.2
unnamed: D7.1 (K), R11.2
unnamed: D8.1 (K), R12.2
unnamed: J1.1, U2.6 (OUTA)
unnamed: J1.2, U2.4 (OUTB)
unnamed: J2.1, U5.6 (OUTA)
unnamed: J2.2, U5.4 (OUTB)
unnamed: J7.2, Q13.5 (D)
unnamed: J13.3, R26.1
unnamed: Q1.3 (D), R10.1
unnamed: Q2.3 (D), R11.1
unnamed: Q3.3 (D), R12.1
RXD0: U6.36 (RXD0); also elsewhere on the board
TXD0: U6.37 (TXD0); also elsewhere on the board

Notes on the sheet:
Fan motor
IMU
Wall sensor LEDs
Arm drivers
Indicators
IR-LED
Processor
Boot strap PullDown
Battery Voltage measurement
Servo motor
LSM6DSR SPI mode = 3 (Latch at rise edges)
Motor drivers
Wall sensor PhTrs
↑ FRONT
PhTr

Parts:
BT1: B2B-PH; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
C23, C24, C25, C33, C34, C35, C38, C40, C41: CC0603KRX7R9BB104; C_0603_1608Metric
C26, C27, C32: CL21A106KAYNNNE; C_0805_2012Metric
C28, C29, C30, C31: CL10A106KP8NNNC; C_0603_1608Metric
C36, C37, C39: CL10A105KB8NNNC; C_0603_1608Metric
D5: KT-0603R; LED_0603_1608Metric
J9: B2B-PH; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J10, J12: FSS-42085-03; PinHeader_2x03_P2.54mm_Vertical
Q5, Q6: DMT6008LFG; Diodes_PowerDI3333-8
Q7, Q8: DTC114E; SOT-723
R18, R21: 0603WAF1001T5E; R_0603_1608Metric
R19: 0603WAF3300T5E; R_0603_1608Metric
R20: 0603WAF100JT5E; R_0603_1608Metric
R22: 0603WAF1301T5E; R_0603_1608Metric
SW1: B3U-1000P; SW_SPST_B3U-1000P
U12: OKL-T/6-W12N-C; OKL-T&slash_6-W12N-C_MUR
U13: XC6221B332MR; SOT-23-5
U14, U16: LM74700QDBVRQ1; SOT-23-6
U15: MCP73213T-A6SI/MF; DFN-10-1EP_3x3mm_P0.5mm_EP1.58x2.35mm
U17: FT231XQ-R; QFN-20-1EP_4x4mm_P0.5mm_EP2.5x2.5mm

Connections:
+3V3: C31.2, U13.5 (VOUT); also elsewhere on the board
+5V: C27.1, C28.2, C29.2, C30.2, C32.1, J10.5, J10.6, U12.4 (Vout), U12.5 (Sense), U13.1 (VIN), U13.3 (CE); also elsewhere on the board
+BATT: C25.2, C26.2, C35.2, J10.1, J10.2, Q5.5 (D), Q6.5 (D), U12.2 (Vin), U14.4 (CATHODE), U16.4 (CATHODE); also elsewhere on the board
/Power/DTR: Q7.1 (B), Q8.2 (E), U17.18 (~DTR)
/Power/EXT_PWR: C23.2, C24.2, C36.2, D5.2 (A), J9.1, Q5.1 (S), Q5.2 (S), Q5.3 (S), U14.3 (EN), U14.6 (ANODE), U15.1 (VDD), U15.2 (VDD)
/Power/RTS: Q7.2 (E), Q8.1 (B), U17.19 (~RTS)
/Power/USB_DM: J12.1, U17.9 (USBDM)
/Power/USB_DP: J12.2, U17.8 (USBDP)
CHIP_PU: C39.2, Q7.3 (C), SW1.2; also elsewhere on the board
GND: BT1.2 (-), C23.1, C25.1, C26.1, C27.2, C28.1, C29.1, C30.1, C31.1, C32.2, C33.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, J9.2, J10.3, J10.4, J12.4, J12.5, J12.6, R20.2, R22.2, SW1.1, U12.1 (ON/OFF), U12.3 (GND), U12.7 (GND), U13.2 (GND), U14.2 (GND), U15.8 (VSS), U15.9 (VSS), U15.11 (EP), U16.2 (GND), U17.3 (GND), U17.13 (GND), U17.21 (GND); also elsewhere on the board
GPIO0: C40.2, Q8.3 (C); also elsewhere on the board
unnamed: BT1.1 (+), C33.2, C34.2, C37.2, Q6.1 (S), Q6.2 (S), Q6.3 (S), U15.3 (VBAT), U15.4 (VBAT), U16.3 (EN), U16.6 (ANODE)
unnamed: D5.1 (K), R21.2
unnamed: Q5.4 (G), U14.5 (GATE)
unnamed: Q6.4 (G), U16.5 (GATE)
unnamed: R18.2, R19.1
unnamed: R19.2, R20.1
unnamed: R18.1, U12.6 (Trim)
unnamed: C24.1, U14.1 (VCAP)
unnamed: R22.1, U15.10 (PROG)
unnamed: R21.1, U15.7 (STAT)
unnamed: C34.1, U16.1 (VCAP)
unnamed: C41.2, U17.10 (3V3OUT), U17.11 (~RESET), U17.20 (VCCIO)
RXD0: U17.17 (TXD); also elsewhere on the board
TXD0: U17.1 (RXD); also elsewhere on the board
VBUS: C38.2, J12.3, U17.12 (VCC)

Notes on the sheet:
Charge current = 850mA
DC power source
Power supply for RPi 5V Max5A
5V Max6A
Power management
Power supply
USB I/F for RPi
Reset switch
USB-Serial I/F
